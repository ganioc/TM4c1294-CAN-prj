# IAR project usb_dev_cserial.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT; UART_BUFFERED; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: usb_dev_cserial.bin
  ILINK.IlinkOutputFile: usb_dev_cserial.out
  ILINK.IlinkIcfFile: usb_dev_cserial.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../usblib/ewarm/Exe/: usblib.a
  group Source
    ../../../../utils/: cmdline.c ustdlib.c
    ../drivers/: pinout.c
    ./: startup_ewarm.c usb_dev_cserial.c usb_structs.c
